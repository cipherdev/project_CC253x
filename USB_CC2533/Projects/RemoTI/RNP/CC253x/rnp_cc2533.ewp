# IAR project rnp_cc2533.ewp, settings and files
configuration CC2533F64 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F64.i51
  ICC8051.CCDefines: CC2533F64; INT_HEAP_LEN=1200; POWER_SAVING; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; GENERIC=__generic
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\APPLICATION; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2533EB_NPI; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\..\COMPONENTS\RCN; ..\..\..\..\COMPONENTS\RTI; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MT; ..\..\COMMON\CC2530\; ..\..\COMMON\npi\npi_np; ..\..\COMMON\NV\NONMIGR; ..\..\PROFILES\GDP; ..\..\PROFILES\ZID
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: cc253x_f64.xcl
configuration CC2533F64_HEX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; INT_HEAP_LEN=1200; POWER_SAVING; FEATURE_HEX; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: ..\APPLICATION; ..\..\COMMON\BOOTLOADER; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2533EB_NPI; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\..\COMPONENTS\RCN; ..\..\..\..\COMPONENTS\RTI; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MT; ..\..\COMMON\CC2530\; ..\..\COMMON\npi\npi_np; ..\..\COMMON\NV\NONMIGR; ..\..\PROFILES\GDP; ..\..\PROFILES\ZID
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC253x" "sbl_cc253x.ewp" "CC2533F64_UART0_HEX"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "CC2533F64_HEX\Exe\rnp_cc2533f64" "..\..\SerialBoot\CC253x\CC2533F64_UART0_HEX\Exe\sbl_cc2533f64_uart0.hex" "129"
  XLINK.XclFile: cc253x_f64_hex.xcl
configuration CC2533F64_SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; INT_HEAP_LEN=1200; POWER_SAVING; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: ..\APPLICATION; ..\..\COMMON\BOOTLOADER; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2533EB_NPI; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\..\COMPONENTS\RCN; ..\..\..\..\COMPONENTS\RTI; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MT; ..\..\COMMON\CC2530\; ..\..\COMMON\npi\npi_np; ..\..\COMMON\NV\NV2SNV; ..\..\PROFILES\GDP; ..\..\PROFILES\ZID
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "CC2533F64_SBL\Exe\rnp_cc2533f64_sbl"
  XLINK.XclFile: cc253x_f64_sbl.xcl
configuration CC2533F64_I2C (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; NPI_I2C_MRDY_ACTIVE_LOW; NPI_I2C_SRDY_ACTIVE_LOW; HAL_I2C=TRUE; HAL_I2C_BUF_MAX=128+3+2; HAL_UART=FALSE; INT_HEAP_LEN=1300; POWER_SAVING; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; GENERIC=__generic
configuration CC2533F64_I2C_HEX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; NPI_I2C_MRDY_ACTIVE_LOW; NPI_I2C_SRDY_ACTIVE_LOW; HAL_I2C=TRUE; HAL_I2C_BUF_MAX=128+3+2; HAL_UART=FALSE; INT_HEAP_LEN=1300; POWER_SAVING; FEATURE_HEX; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC253x" "sbl_cc253x.ewp" "CC2533F64_I2C_HEX"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "CC2533F64_I2C_HEX\Exe\rnp_cc2533f64_i2c" "..\..\SerialBoot\CC253x\CC2533F64_I2C_HEX\Exe\sbl_cc2533f64_i2c.hex" "129"
  XLINK.XclFile: cc253x_f64_hex.xcl
configuration CC2533F64_I2C_SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; NPI_I2C_MRDY_ACTIVE_LOW; NPI_I2C_SRDY_ACTIVE_LOW; HAL_I2C=TRUE; HAL_I2C_BUF_MAX=128+3+2; HAL_UART=FALSE; INT_HEAP_LEN=1300; POWER_SAVING; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "CC2533F64_I2C_SBL\Exe\rnp_cc2533f64_i2c_sbl"
  XLINK.XclFile: cc253x_f64_sbl.xcl
configuration CC2533F64_SPI (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; HAL_SPI=TRUE; HAL_UART=FALSE; INT_HEAP_LEN=1200; POWER_SAVING; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; GENERIC=__generic
configuration CC2533F64_SPI_HEX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; HAL_SPI=TRUE; HAL_UART=FALSE; INT_HEAP_LEN=1200; POWER_SAVING; FEATURE_HEX; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC253x" "sbl_cc253x.ewp" "CC2533F64_SPI1_HEX"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "CC2533F64_SPI_HEX\Exe\rnp_cc2533f64_spi" "..\..\SerialBoot\CC253x\CC2533F64_SPI1_HEX\Exe\sbl_cc2533f64_spi1.hex" "129"
  XLINK.XclFile: cc253x_f64_hex.xcl
configuration CC2533F64_SPI_SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2533F64; HAL_SPI=TRUE; HAL_UART=FALSE; INT_HEAP_LEN=1200; POWER_SAVING; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "CC2533F64_SPI_SBL\Exe\rnp_cc2533f64_spi_sbl"
  XLINK.XclFile: cc253x_f64_sbl.xcl
configuration CC2533F96 (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; INT_HEAP_LEN=3200; POWER_SAVING; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; GENERIC=__generic
  XLINK.XclFile: cc253x_f96.xcl
configuration CC2533F96_HEX (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; INT_HEAP_LEN=3200; POWER_SAVING; FEATURE_HEX; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC253x" "sbl_cc253x.ewp" "CC2533F96_UART0_HEX"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "CC2533F96_HEX\Exe\rnp_cc2533f96" "..\..\SerialBoot\CC253x\CC2533F96_UART0_HEX\Exe\sbl_cc2533f96_uart0.hex" "129"
  XLINK.XclFile: cc253x_f96_hex.xcl
configuration CC2533F96_SBL (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; INT_HEAP_LEN=3200; POWER_SAVING; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "CC2533F96_SBL\Exe\rnp_cc2533f96_sbl"
  XLINK.XclFile: cc253x_f96_sbl.xcl
configuration CC2533F96_I2C (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; NPI_I2C_MRDY_ACTIVE_LOW; NPI_I2C_SRDY_ACTIVE_LOW; HAL_I2C=TRUE; HAL_I2C_BUF_MAX=128+3+2; HAL_UART=FALSE; INT_HEAP_LEN=3300; POWER_SAVING; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; GENERIC=__generic
  XLINK.XclFile: cc253x_f96.xcl
configuration CC2533F96_I2C_HEX (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; NPI_I2C_MRDY_ACTIVE_LOW; NPI_I2C_SRDY_ACTIVE_LOW; HAL_I2C=TRUE; HAL_I2C_BUF_MAX=128+3+2; HAL_UART=FALSE; INT_HEAP_LEN=3300; POWER_SAVING; FEATURE_HEX; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC253x" "sbl_cc253x.ewp" "CC2533F96_I2C_HEX"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "CC2533F96_I2C_HEX\Exe\rnp_cc2533f96_i2c" "..\..\SerialBoot\CC253x\CC2533F96_I2C_HEX\Exe\sbl_cc2533f96_i2c.hex" "129"
  XLINK.XclFile: cc253x_f96_hex.xcl
configuration CC2533F96_I2C_SBL (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; NPI_I2C_MRDY_ACTIVE_LOW; NPI_I2C_SRDY_ACTIVE_LOW; HAL_I2C=TRUE; HAL_I2C_BUF_MAX=128+3+2; HAL_UART=FALSE; INT_HEAP_LEN=3300; POWER_SAVING; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "CC2533F96_I2C_SBL\Exe\rnp_cc2533f96_i2c_sbl"
  XLINK.XclFile: cc253x_f96_sbl.xcl
configuration CC2533F96_SPI (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; HAL_SPI=TRUE; HAL_UART=FALSE; INT_HEAP_LEN=3500; POWER_SAVING; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; GENERIC=__generic
  XLINK.XclFile: cc253x_f96.xcl
configuration CC2533F96_SPI_HEX (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; HAL_SPI=TRUE; HAL_UART=FALSE; INT_HEAP_LEN=3500; POWER_SAVING; FEATURE_HEX; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC253x" "sbl_cc253x.ewp" "CC2533F96_SPI1_HEX"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "CC2533F96_SPI_HEX\Exe\rnp_cc2533f96_spi" "..\..\SerialBoot\CC253x\CC2533F96_SPI1_HEX\Exe\sbl_cc2533f96_spi1.hex" "129"
  XLINK.XclFile: cc253x_f96_hex.xcl
configuration CC2533F96_SPI_SBL (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; HAL_SPI=TRUE; HAL_UART=FALSE; INT_HEAP_LEN=3500; POWER_SAVING; FEATURE_SBL; FEATURE_TEST_MODE; FEATURE_ZID_CLD=FALSE; FEATURE_ZID_ADA=TRUE; ASSERT_RESET; GENERIC=__generic
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "CC2533F96_SPI_SBL\Exe\rnp_cc2533f96_spi_sbl"
  XLINK.XclFile: cc253x_f96_sbl.xcl
  group Application
    ../../../../Components/mac/low_level/srf04/single_chip/: mac_rffrontend.c
    ../Application/: np_main.c np_main.h
    ../../../../Components/rcn/: rcn_config.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../COMPONENTS/hal/include/: hal_adc.h hal_assert.h hal_batmon.h hal_board.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h hal_vddmon.h
  group HAL/Target/CC2533EB_NPI
    ../../../../Components/hal/target/CC2533EB_NPI/: hal_aes.c hal_batmon.c hal_ccm.c hal_dma.c hal_flash.c hal_i2c.c hal_sleep.c hal_spi.c hal_startup.c hal_uart.c hal_vddmon.c
    ../../../../COMPONENTS/hal/target/CC2533EB_NPI/: hal_aes.h hal_board_cfg.h hal_dma.h hal_i2c.h hal_mac_cfg.h hal_mcu.h hal_spi.h hal_types.h
  group OSAL
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 osal_snv.c
  group PROFILES/GDP
    ../../Profiles/gdp/: gdp.c gdp.h gdp_profile.h
    ../../../../Components/rti/: rti.c rti_testmode.c
    ../../../../COMPONENTS/rti/: rti.h rti_constants.h
  group PROFILES/ZID
    ../../Profiles/zid/: zid_adaptor.c zid_adaptor.h zid_class_device.c zid_class_device.h zid_common.c zid_common.h zid_profile.h
  group RPC
    ../../common/npi/npi_np/: npi.c npi.h
    ../../../../Components/rcn/: rcns.c
    ../../common/rtis/: rtis_np.c
  group SerialBoot
    ../../common/bootloader/: sb_load.h sb_target.c
