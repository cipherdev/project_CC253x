# IAR project rsa_cc2533_rtm.ewp, settings and files
configuration CC2533F64 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F64.i51
  ICC8051.CCDefines: CC2533F64; FEATURE_CONTROLLER_ONLY; FEATURE_ZID_CLD=TRUE; POWER_SAVING; ASSERT_RESET; GENERIC=__generic; INT_HEAP_LEN=1024
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\APPLICATION; ..\..\COMMON\CC2530\; ..\..\PROFILES\GDP; ..\..\PROFILES\ZID; ..\..\COMMON\NPI\NPI_NP; ..\..\COMMON\NV\NONMIGR; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2533ARC_RTM; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\..\COMPONENTS\RCN; ..\..\..\..\COMPONENTS\RTI; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MT
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: cc253x_f64.xcl
configuration CC2533F64-HEX (8051)
  as the first configuration, except:
configuration CC2533F96 (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: CC2533F96; FEATURE_CONTROLLER_ONLY; FEATURE_ZID_CLD=TRUE; POWER_SAVING; ASSERT_RESET; GENERIC=__generic; INT_HEAP_LEN=1024
  XLINK.XclFile: cc253x_f96.xcl
configuration CC2533F96-HEX (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2533F96.i51
  ICC8051.CCDefines: as above
  XLINK.XclFile: cc253x_f96.xcl
  group Application
    ../../../../Components/rcn/: rcn_config.c
    ../Application/: rsa.h rsa_main.c rsa_osal.c rsa_point.c
    ../../Profiles/zid/: zid_cld_app_helper.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../COMPONENTS/hal/include/: hal_rpc.h
  group HAL/Target/CC2533ARC_RTM
    ../../../../Components/hal/target/CC2533ARC_RTM/: AIR_MOTION_LIB_3G3A-Banked.r51 AIR_MOTION_LIB_3G3A-NEAR.r51 hal_accel.c hal_accel.h hal_aes.c hal_aes.h hal_batmon.c hal_buzzer.c hal_ccm.c hal_dma.c hal_dma.h hal_flash.c hal_gpiodbg.c hal_gyro.c hal_i2c.c hal_key.c hal_motion.c hal_motion.h hal_sleep.c hal_startup.c hal_vddmon.c
    ../../../../COMPONENTS/hal/target/CC2533ARC_RTM/: hal_board_cfg.h hal_buzzer.h hal_gpiodbg.h hal_gyro.h hal_i2c.h
  group OSAL
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 osal_snv.c
  group PROFILES/GDP
    ../../Profiles/gdp/: gdp.c gdp.h gdp_profile.h
    ../../../../Components/rti/: rti.c rti_testmode.c
    ../../../../COMPONENTS/rti/: rti.h rti_constants.h
  group PROFILES/ZID
    ../../Profiles/zid/: zid_class_device.c zid_class_device.h zid_common.c zid_common.h zid_hid_constants.h zid_profile.h
