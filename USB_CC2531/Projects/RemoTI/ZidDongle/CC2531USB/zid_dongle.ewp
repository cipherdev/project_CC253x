# IAR project zid_dongle.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=4096; FEATURE_TEST_MODE; FEATURE_ZID_ADA=TRUE; FEATURE_ZID_ZRC=TRUE; FEATURE_ZID_ADA_TST=FALSE; HAL_KEY=TRUE; HAL_LED=TRUE; BLINK_LEDS=TRUE; RCN_CAP_PAIR_TABLE_SIZE=2; POWER_SAVING; GENERIC=__generic; ZID_USB_RNP; ZID_USB_CE; HAL_UART=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\APPLICATION; ..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2531HID_NPI; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2531HID_NPI\usb; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2531HID_NPI\usb\library; ..\..\..\..\COMPONENTS\HAL\TARGET\CC2531HID_NPI\usb\class_zid; ..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\..\COMPONENTS\RCN; ..\..\..\..\COMPONENTS\RTI; ..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\COMPONENTS\MT; ..\..\common\cc2530; ..\..\PROFILES\gdp; ..\..\PROFILES\zid; ..\..\COMMON\npi\npi_np; ..\..\COMMON\NV\NONMIGR; ..\..\COMMON\rtis
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ti_51ew_cc2530f256.xcl
configuration Hex (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=4096; FEATURE_TEST_MODE; FEATURE_ZID_ADA=TRUE; FEATURE_ZID_ZRC=TRUE; FEATURE_ZID_ADA_TST=FALSE; HAL_KEY=TRUE; HAL_LED=TRUE; BLINK_LEDS=TRUE; RCN_CAP_PAIR_TABLE_SIZE=2; POWER_SAVING; GENERIC=__generic; ZID_USB_RNP; ZID_USB_CE; HAL_UART=FALSE; FEATURE_HEX; FEATURE_SBL
  prebuild: "..\..\common\cc2530\cc253x_sbl_pre.bat" "$EW_DIR$" "..\..\SerialBoot\CC2531USB" "bootloader_cc2531.ewp" "ReleaseNonNano"
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdHex" "Hex\Exe\zid_dongle" "..\..\SerialBoot\CC2531USB\ReleaseNonNano\Exe\bootloader_cc2531.hex" "385"
  XLINK.XclFile: cc2531_f256_hex.xcl
configuration SB_image (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=4096; FEATURE_TEST_MODE; FEATURE_ZID_ADA=TRUE; FEATURE_ZID_ZRC=TRUE; FEATURE_ZID_ADA_TST=FALSE; HAL_KEY=TRUE; HAL_LED=TRUE; BLINK_LEDS=TRUE; RCN_CAP_PAIR_TABLE_SIZE=2; POWER_SAVING; GENERIC=__generic; ZID_USB_RNP; ZID_USB_CE; HAL_UART=FALSE; FEATURE_SBL
  postbuild: "..\..\common\cc2530\cc253x_sbl_pp.bat" "$PROJ_DIR$" "ProdSBL" "SB_image\Exe\zid_dongle"
  XLINK.XclFile: cc2531_f256_sbl.xcl
  group Application
    ../Application/: np_main.c np_main.h zid_dongle.c zid_dongle.h zid_proxy.c zid_proxy.h zid_usb.c zid_usb.h
    ../../common/cc2530/: OnBoard.c
    ../../../../Components/rcn/: rcn_config.c
    ../../Profiles/zid/: zid_ada_app_helper.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../COMPONENTS/hal/include/: hal_adc.h hal_assert.h hal_batmon.h hal_board.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h hal_vddmon.h
  group HAL/Target/CC2531HID_NPI
    ../../../../Components/hal/target/CC2531HID_NPI/: hal_adc.c hal_aes.c hal_aes.h hal_board_cfg_nano.h hal_ccm.c hal_dma.c hal_dma.h hal_flash.c hal_key.c hal_led.c hal_sleep.c hal_startup.c hal_uart.c hal_vddmon.c
    ../../../../COMPONENTS/hal/target/CC2531HID_NPI/: hal_board_cfg.h hal_mac_cfg.h hal_mcu.h hal_types.h
  group HAL/Target/CC2531HID_NPI/usb
    ../../../../COMPONENTS/hal/target/CC2531HID_NPI/usb/: usb_board_cfg.h usb_descriptor.h
    ../../../../Components/hal/target/cc2531hid_npi/usb/: usb_interrupt.c usb_suspend.c
  group HAL/Target/CC2531HID_NPI/usb/class_zid
    ../../../../Components/hal/target/cc2531hid_npi/usb/class_zid/: usb_zid.c usb_zid.h usb_zid_class_requests.c usb_zid_descriptor.c usb_zid_hooks.c usb_zid_reports.c
    ../../../../COMPONENTS/hal/target/CC2531HID_NPI/usb/class_zid/: usb_zid_class_requests.h usb_zid_reports.h
  group HAL/Target/CC2531HID_NPI/usb/library
    ../../../../Components/hal/target/cc2531hid_npi/usb/library/: usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_standard_requests.c usb_standard_requests.h
    ../../../../COMPONENTS/hal/target/CC2531HID_NPI/usb/library/: usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_suspend.h
  group OSAL
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 osal_snv.c
  group PROFILES/GDP
    ../../Profiles/gdp/: gdp.c gdp.h gdp_profile.h
    ../../../../Components/rti/: rti.c rti_testmode.c
    ../../../../COMPONENTS/rti/: rti.h rti_constants.h
  group PROFILES/ZID
    ../../Profiles/zid/: zid_adaptor.c zid_adaptor.h zid_common.c zid_common.h zid_hid_constants.h zid_profile.h
